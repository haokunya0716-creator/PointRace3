# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C """D:\TI\M0_SDK\mspm0_sdk_2_02_00_05\tools\keil\syscfg.bat"" "$P" "empty.syscfg""
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSPM0G3507__
  c include: ..;..\Application;..\Board;..\Button;..\hardware;..\IMU;..\keil;..\LCD;..\MSP_Motor_Ctrl;..\MSPM0;..\PID;..\source;..\ti;..\VL53L0X;..\source\third_party\CMSIS\Core\Include;..\source\third_party\CMSIS\Core\Include;..\..\source;..\MSP_Motor_Ctrl;..\App_Task;..\Motor;..\Vision
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: "D:\TI\M0_SDK\mspm0_sdk_2_02_00_05\PointRace3\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a"
  group Source
    ../: empty.c empty.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
    ./: startup_mspm0g350x_uvision.s
  group MSPMotor_Ctl
    ../MSP_Motor_Ctrl/: user.c user.h
  group Driverlib
    ../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/: driverlib.a
  group MSPM0
    ../MSPM0/: clock.c interrupt.c task.h clock.h interrupt.h
  group IMU
    ../IMU/: imu.c imu.h
  group Application
    ../Application/: app_vl5310x.c app_vl5310x.h app_linedetect.c app_linedetect.h app_PWM.c app_PWM.h
    ./: app_button.c app_button.h app_bat.c app_bat.h app_motor.c app_motor.h app_speed.c app_speed.h
  group VL53L0X
    ../VL53L0X/: vl53l0x.c vl53l0x.h vl53l0x_api.c vl53l0x_api.h vl53l0x_api_calibration.c vl53l0x_api_calibration.h vl53l0x_api_core.c vl53l0x_api_core.h vl53l0x_api_ranging.c vl53l0x_api_ranging.h vl53l0x_api_strings.c vl53l0x_api_strings.h vl53l0x_def.h vl53l0x_device.h vl53l0x_interrupt_threshold_settings.h vl53l0x_platform.c vl53l0x_platform.h vl53l0x_platform_log.c vl53l0x_platform_log.h vl53l0x_tuning.h vl53l0x_types.h
  group Board
    ../Board/: board.c board.h
  group PID
    ../PID/: pid.c pid.h
  group Button
    ../Button/: button.c button.h
  group App_Task
    ./: app_task.c app_task.h app_task4.c app_task4.h
  group Motor
    ./: motor.c motor.h app_encoder.h app_encoder.c
  group Vision
    ../Vision/: vision.h vision.c
